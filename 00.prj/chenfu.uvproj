# Keil uVision project chenfu.uvproj, settings and files
target chenfu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MD_Bootloader_6A_232_485 +hex
  AfterMake: fromelf --bin --output @L.bin "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_STM322xG_EVAL,STM32F2XX
  c include: ..\01.app;..\08.stdlib\00.inc;..\08.stdlib\01.src;..\08.stdlib\02.cm3;..\08.stdlib\04.sys;..\08.stdlib\05.startup;..\06.bsp\00.gpio;..\02.cmm\00.type;..\02.cmm\01.queue;..\06.bsp\01.usart;..\06.bsp\02.nvic;..\09.Debug\00.usart_debug;..\06.bsp\03.flash;..\04.pro\00.zld;..\02.cmm\02.common;..\06.bsp\04.backup;..\06.bsp\05.watchdog;..\06.bsp\06.tim;..\03.data\00.fileOperate;..\06.bsp\07.eeprom
  memory RVCT4: ROM 0x8000000 size 0x3ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01.app
    ../01.app/: app_cfg.h main.c includes.h bsp.c bsp.h jumpApp.c jumpApp.h upgradeKey.c upgradeKey.h interface_SW.c interface_SW.h
  group 02.cmm
    ../02.cmm/00.type/: type.h
    ../02.cmm/01.queue/: queue.c queue.h
    ../02.cmm/02.common/: common.c common.h
  group 03.data
    ../03.data/00.fileOperate/: fileopt.c fileopt.h
  group 04.pro
    ../04.pro/00.zld/: upgrade_pro.c upgrade_pro.h
  group 06.bsp
    ../06.bsp/00.gpio/: gpio.c gpio.h
    ../06.bsp/01.usart/: usart2_485.c usart2_485.h usart1_232.c usart1_232.h
    ../06.bsp/02.nvic/: nvic_config.c nvic_config.h
    ../06.bsp/03.flash/: flash_interCtr.c flash_interCtr.h
    ../06.bsp/04.backup/: backup.c backup.h
    ../06.bsp/05.watchdog/: watchdog.c watchdog.h
    ../06.bsp/06.tim/: tim_5.c tim_5.h
    ../06.bsp/07.eeprom/: FM24CL16.c FM24CL16.h
  group 08.stdlib
    ../08.stdlib/00.inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ../08.stdlib/01.src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../08.stdlib/02.cm3/: core_cm3.c core_cm3.h
    ../08.stdlib/04.sys/: stm32f2xx_conf.h stm32f2xx_it.h system_stm32f2xx.c stm32f2xx.h system_stm32f2xx.h
    ../08.stdlib/05.startup/: startup_stm32f2xx.s
  group 09.debug
    ../09.Debug/00.usart_debug/: usart_debug.c
